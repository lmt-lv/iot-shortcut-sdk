## boards/lmt/lmt9151som/board.yml
```yaml
board:
  name: lmt9151som
  full_name: "LMT IoT SoM nRF9151"
  vendor: lmt iot
  socs:
  - name: nrf9151
    variants:
    - name: 'ns'
```
